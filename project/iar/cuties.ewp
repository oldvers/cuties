# IAR project cuties.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $CUTIES_CFG_DIR$; ..\..\source; ..\..\source\freertos\Source\include; ..\..\source\freertos\Source\portable\IAR\ARM_CM3; ..\..\source\log; ..\..\source\block_queue; ..\..\source\east
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $CUTIES_CFG_DIR$
  OBJCOPY.OOCOutputFile: STM32F103C8_BluePill.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BlockQueue
    ../../source/block_queue/: block_queue.c block_queue.h
  group EAST
    ../../source/east/: east_packet.c east_packet.h
  group FIFO
    ../../source/fifo/: fifo.c fifo.h
  group Log
    ../../source/log/: log.c log.h
  group RTOS
    ../../source/freertos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../source/freertos/Source/include/: FreeRTOS.h
    ../../configuration/: FreeRTOSConfig.h
    ../../source/freertos/Source/portable/MemMang/: heap_2.c
    ../../source/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
