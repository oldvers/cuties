# IAR project test_simulator_template.ewp, settings and files
configuration test (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB; STM32F10X_MD; DBG_NONE
  ICCARM.CCIncludePath2: ..\..\source; ..\..\..\..\..\source; ..\..\..\..\..\source\log; ..\..\..\..\..\source\freertos; ..\..\..\..\..\source\freertos\Source\include; ..\..\..\..\..\source\freertos\Source\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\source\freertos
  OBJCOPY.OOCOutputFile: STM32F103C8_BluePill.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkExtraOptions: --whole_archive ..\..\..\..\..\project\iar\build\release\exe\cuties.a
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\project\iar\build\release\exe\cuties.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Main
    ../../../../source/: main.c
    ../../source/: mocks.c test.c
