# IAR project test_east_block.ewp, settings and files
configuration test (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $CUTIES_CFG_DIR$; ..\..\source; ..\..\..\..\..\source; ..\..\..\..\..\source\log; ..\..\..\..\..\source\freertos; ..\..\..\..\..\source\freertos\Source\include; ..\..\..\..\..\source\freertos\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\source\block_queue; ..\..\..\..\..\source\east
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $CUTIES_CFG_DIR$; ..\..\..\..\..\source\freertos
  OBJCOPY.OOCOutputFile: STM32F103C8_BluePill.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkExtraOptions: --whole_archive ..\..\..\..\..\project\iar\build\release\exe\cuties.a
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\project\iar\build\release\exe\cuties.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Main
    ../../../../source/: main.c
    ../../source/: mocks.c test.c
